# Keil uVision project usb_disk_test.uvproj, settings and files
target usb_disk_test (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: 139W +hex
  c flags: Optim=1
  c include: ..\inc;..\src;..\src\APP;..\src\Hardware\CSSP;..\src\Hardware;..\src\Board;..\src\Share;..\src\Hardware\I2C;..\src\Hardware\Timer;..\src\Hardware\GPIO;..\src\Hardware\UART;..\src\10Task;..\src\20RunCtrl;..\src\Hardware\Extint;..\src\11DisMenu;..\src\12UARTHandle;..\src\13CirCon;..\src\14Sand195;..\src\SysCtrl;..\src\CRunCtrl;..\src\CLpCtrl;..\src\CTimeCtrl;..\src\CHardware;..\src\CNodeInfo;..\src\Hardware\IRQ;..\src\componentinfo;..\src\MenuCtrl;..\src\CLoopCtrl;..\src\common;..\src\Menu;..\src\common;..\src\timesharectrl
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group startup
    ../src/: startup_LPC17xx.s
  group Source Group
    ../src/: core_cm3.c system_LPC17xx.c
  group APP
    ../src/APP/: main.c main.h Config.h include.h
  group HardWare
    ../src/Hardware/CSSP/: ssp.c ssp.h
    ../src/Hardware/: Delay.c Delay.h PWM.c PWM.h
    ../src/Hardware/I2C/: i2c.c i2c.h
    ../src/Hardware/UART/: uart.c uart.h
    ../src/Hardware/GPIO/: GPIOInit.C GPIOInit.h
    ../src/Hardware/Timer/: CTime.c CTime.h CTimeDef.c CTimeDef.h
    ../src/Hardware/Extint/: extint.c extint.h
    ../src/Hardware/IRQ/: CGpioIrq.c CGpioIrq.h
  group Board
    ../src/Board/: lcd.c lcd.h pcf8563.c pcf8563.h key.c key.h CLED.c CLED.h CRelay.c CRelay.h
  group 12 UartHandle
    ../src/12UARTHandle/: CComHandle.c CComHandle.h CComPara.c CComPara.h CComAnn.c CComAnn.h
  group 13 CircuitCon
    ../src/13CirCon/: CAddressCount.c CAddressCount.h
  group 14 Send195
    ../src/14Sand195/: CSendTo195.c CSendTo195.h
  group MenuCtrl
    ../src/MenuCtrl/: CGetGrap.c CGetGrap.h CKeyCounter.c CKeyCounter.h CTaskDown.c CTaskDown.h CTaskReturn.c CTaskReturn.h CTaskSure.c CTaskSure.h CTaskUp.c CTaskUp.h runfunction.c runfunction.h tasklist.c tasklist.h
  group timersharectrl
    ../src/timesharectrl/: SysCtrl.c SysCtrl.h
  group CRunCtrl
    ../src/CRunCtrl/: CRunCtrl.c CRunCtrl.h CSysRunFlag.c CSysRunFlag.h CSoftVerDef.h
  group CLoopCtrl
    ../src/CLoopCtrl/: CLpAnsCtrl.c CLpAnsCtrl.h CLpCkCtrl.c CLpCkCtrl.h CLpInfoDef.h CLpScanCtrl.c CLpScanCtrl.h
  group CTimeCtrl
    ../src/CTimeCtrl/: CTimeCtrl.c CTimeCtrl.h
  group CNodeInfo
    ../src/CNodeInfo/: CNodeInfo.c CNodeInfo.h
  group componentinfo
    ../src/componentinfo/: componentinfo.c componentinfo.h store_addr.c store_addr.h
  group Menu
    ../src/Menu/: alarmenu.c alarmenu.h batteryLow.c batteryLow.h breakdown.c breakdown.h CAnnotate.c CAnnotate.h CCompInten.c CCompInten.h CCompReg.c CCompReg.h CCompSet.c CCompSet.h CCompStat.c CCompStat.h CDateMod.c CDateMod.h checkmenu.c checkmenu.h CHistoryList.c CHistoryList.h CLocalSet.c CLocalSet.h CModelFault.c CModelFault.h CSysCheck.c CSysCheck.h CSysReset.c CSysReset.h CTestSelf.c CTestSelf.h mainmenu.c mainmenu.h setmenu.c setmenu.h startmenu.c startmenu.h testmenu.c testmenu.h
  group common
    ../src/common/: 16by16ziku.h buffer.c buffer.h CFlashParam.c CFlashParam.h CGetCompSum.c CGetCompSum.h CGrapParam.c CGrapParam.h CIntStEnd.c CIntStEnd.h CMaDefine.h CSendToFlash.c CSendToFlash.h CSetCurrent.c CSetCurrent.h CSpeaker.c CSpeaker.h CTimerTask.c CTimerTask.h hzk12by12.h hzk16by16 - 3500常用汉字.h hzk16by16 - 所有汉字.h hzk16by16.h HZK16F.h ziku.h CFlash_ADDR_Def.h
